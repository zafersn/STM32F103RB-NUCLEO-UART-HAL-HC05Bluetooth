<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HC05-USART1.ewp</path>
  </project>
  <batchBuild />
</workspace>
